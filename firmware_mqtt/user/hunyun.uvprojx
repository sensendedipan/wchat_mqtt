# Keil uVision project hunyun.uvprojx, settings and files
target firmware (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: output +hex
  AfterMake: C:\Kei5\ARM\ARMCC\bin\fromelf.exe --bin -o  ..\output\huayun.bin ..\output\output.axf
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c misc: --c99
  c include: ..\cmsis;..\system\portable\RVDS\ARM_CM4F;..\user;..\lib\src;..\lib\inc;..\drivers;.\ethernet\net;.\ethernet\w5500;..\system\include;..\system;.\mqtt;.\msg
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --entry Reset_Handler --first __Vectors
  group startcode
    ../cmsis/startup/: startup_stm32f40_41xxx.s
  group cmsis
    ../cmsis/: system_stm32f4xx.c
  group lib
    ../lib/src/: misc.c stm32f4xx_adc.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_pwr.c stm32f4xx_dma.c
  group system
    ../system/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../system/portable/RVDS/ARM_CM4F/: port.c
    ../system/portable/MemMang/: heap_4.c
  group user
    ./: main.c main.h freeRTOSconfig.h debug.h eeprom.h data_struct.h stm32f4xx_it.c
  group tasks
    ./task/: task_wdg.c task_web.c task_mqtt.c
  group drivers
    ../drivers/: board.c flash.c fifo.c fiforx.c led_driver.c inout_driver.c sim_driver.c i2c_driver.c i2c2_driver.c spi1_driver.c adc_driver.c spi2_driver.c at24cx_driver.c w25qx_driver.c usart1_driver.c usart2_driver.c usart3_driver.c usart6_driver.c usart4_driver.c timer2_driver.c timer3_driver.c timer4_driver.c timer5_driver.c wdg_driver.c crc16.c
  group w5500
    ./ethernet/w5500/: w5500_conf.c w5500_conf.h socket.c socket.h w5500.c w5500.h utility.c utility.h types.h
  group net
    ./ethernet/net/: dhcp.c dhcp.h web_server.c web_server.h webpge.h webutil.c webutil.h netbios.c netbios.h ntp.h udp.c udp.h dns.c dns.h
  group mqtt
    ./mqtt/: mqtthelper.c MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group msg
    ./msg/: message.c
